v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {sky130_fd_pr/res_xhigh_po.sym} -220 -130 0 0 {name=R1
W=5
L=640.15997
model=res_xhigh_po
spiceprefix=X
mult=1}
C {ipin.sym} -220 -160 0 0 {name=p1 lab=A}
C {ipin.sym} -240 -130 0 0 {name=p2 lab=VSS}
C {ipin.sym} -220 -100 0 0 {name=p3 lab=B}
