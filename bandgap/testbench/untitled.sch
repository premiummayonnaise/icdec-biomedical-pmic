v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {icdec-biomedical-pmic/bandgap/bandgap5.sym} 240 -160 0 0 {name=x1}
