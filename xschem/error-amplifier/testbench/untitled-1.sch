v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {icdec-biomedical-pmic/xschem/error-amplifier/schematics/error-amplifier-module.sym} 100 -80 0 0 {name=x1}
